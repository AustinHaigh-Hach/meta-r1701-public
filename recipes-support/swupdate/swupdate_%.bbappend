SWUPDATE_SIGNING = "RSA"
SWUPDATE_PRIVATE_KEY = "/tmp/key"
